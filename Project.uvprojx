# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053R8_NUCLEO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,
  c misc: --C99
  c include: .\lib\STM32_USB_Device_Library\Core\Inc;.\lib\STM32_USB_Device_Library\Class\CustomHID\Inc;.\lib\STM32L0xx_HAL_Driver\Inc;.\src;.\driver\;.\driver\CMSIS;.\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group src
    ./src/: bochiot_protocol.c main.c i2c.c lora.c flash.c ekey.c adc.c rtc.c
  group driver
    ./DRIVER/: stm32l0xx_hal_msp.c stm32l0xx_it.c stm32l0xx_nucleo.c sx1272-Lora.c uart_debug.c usbd_conf.c usbd_desc.c crc.c
    ./driver/: timer.c
  group lib
    ./lib/: system_stm32l0xx.c
    ./lib/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
    ./lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./lib/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group core
    ./CORE/: startup_stm32l053xx.s
